# Keil uVision project LaserSensor.uvproj, settings and files
target LaserSensor (ARM-ADS)
  device: STM32F302RC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(72000000) ELITTLE
  output: LaserSensor
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 uC99=1
  c define: TARGET_RTOS_M4_M7, TARGET_FF_ARDUINO, __CORTEX_M4, TARGET_NUCLEO_F302R8, TARGET_STM32F302R8, TARGET_LIKE_MBED, TARGET_CORTEX_M, MBED_BUILD_TIMESTAMP=1460689976, __FPU_PRESENT=1, TARGET_LIKE_CORTEX_M4, TARGET_M4, __MBED__=1, TARGET_STM, ARM_MATH_CM4, TARGET_STM32F3, TARGET_FF_MORPHO, TOOLCHAIN_ARM, TOOLCHAIN_ARM_STD, __ASSERT_MSG
  c misc: --gnu --no_rtti
  c include: .; mbed; mbed/TARGET_NUCLEO_F302R8; mbed/TARGET_NUCLEO_F302R8/TARGET_STM; mbed/TARGET_NUCLEO_F302R8/TARGET_STM/TARGET_STM32F3; mbed/TARGET_NUCLEO_F302R8/TARGET_STM/TARGET_STM32F3/TARGET_NUCLEO_F302R8; mbed/TARGET_NUCLEO_F302R8/TOOLCHAIN_ARM_STD
  asm define: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: mbed/TARGET_NUCLEO_F302R8/TOOLCHAIN_ARM_STD/stm32f302x8.sct
  group Include Files
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h buffer.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_api.h can_helper.h CircularBuffer.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h dma_api.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h ticker_api.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h us_ticker_api.h wait_api.h
    mbed/TARGET_NUCLEO_F302R8/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis.h cmsis_nvic.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h hal_tick.h stm32f302x8.h stm32f3xx.h stm32f3xx_hal.h stm32f3xx_hal_adc.h stm32f3xx_hal_adc_ex.h stm32f3xx_hal_can.h stm32f3xx_hal_cec.h stm32f3xx_hal_comp.h stm32f3xx_hal_comp_ex.h stm32f3xx_hal_conf.h stm32f3xx_hal_cortex.h stm32f3xx_hal_crc.h stm32f3xx_hal_crc_ex.h stm32f3xx_hal_dac.h stm32f3xx_hal_dac_ex.h stm32f3xx_hal_def.h stm32f3xx_hal_dma.h stm32f3xx_hal_dma_ex.h stm32f3xx_hal_flash.h stm32f3xx_hal_flash_ex.h stm32f3xx_hal_gpio.h stm32f3xx_hal_gpio_ex.h stm32f3xx_hal_hrtim.h stm32f3xx_hal_i2c.h stm32f3xx_hal_i2c_ex.h stm32f3xx_hal_i2s.h stm32f3xx_hal_i2s_ex.h stm32f3xx_hal_irda.h stm32f3xx_hal_irda_ex.h stm32f3xx_hal_iwdg.h stm32f3xx_hal_nand.h stm32f3xx_hal_nor.h stm32f3xx_hal_opamp.h stm32f3xx_hal_opamp_ex.h stm32f3xx_hal_pccard.h stm32f3xx_hal_pcd.h stm32f3xx_hal_pcd_ex.h stm32f3xx_hal_pwr.h stm32f3xx_hal_pwr_ex.h stm32f3xx_hal_rcc.h stm32f3xx_hal_rcc_ex.h stm32f3xx_hal_rtc.h stm32f3xx_hal_rtc_ex.h stm32f3xx_hal_sdadc.h stm32f3xx_hal_smartcard.h stm32f3xx_hal_smartcard_ex.h stm32f3xx_hal_smbus.h stm32f3xx_hal_spi.h stm32f3xx_hal_sram.h stm32f3xx_hal_tim.h stm32f3xx_hal_tim_ex.h stm32f3xx_hal_tsc.h stm32f3xx_hal_uart.h stm32f3xx_hal_uart_ex.h stm32f3xx_hal_usart.h stm32f3xx_hal_usart_ex.h stm32f3xx_hal_wwdg.h stm32f3xx_ll_fmc.h system_stm32f3xx.h
    mbed/TARGET_NUCLEO_F302R8/TARGET_STM/TARGET_STM32F3/TARGET_NUCLEO_F302R8/: device.h objects.h PeripheralNames.h PinNames.h PortNames.h
    mbed/TARGET_NUCLEO_F302R8/TARGET_STM/TARGET_STM32F3/: gpio_object.h PeripheralPins.h
  group Source Files
    mbed/TARGET_NUCLEO_F302R8/TOOLCHAIN_ARM_STD/: board.o cmsis_nvic.o hal_tick.o mbed.ar mbed_overrides.o retarget.o startup_stm32f302x8.o stm32f3xx_hal.o stm32f3xx_hal_adc.o stm32f3xx_hal_adc_ex.o stm32f3xx_hal_can.o stm32f3xx_hal_cec.o stm32f3xx_hal_comp.o stm32f3xx_hal_cortex.o stm32f3xx_hal_crc.o stm32f3xx_hal_crc_ex.o stm32f3xx_hal_dac.o stm32f3xx_hal_dac_ex.o stm32f3xx_hal_dma.o stm32f3xx_hal_flash.o stm32f3xx_hal_flash_ex.o stm32f3xx_hal_gpio.o stm32f3xx_hal_hrtim.o stm32f3xx_hal_i2c.o stm32f3xx_hal_i2c_ex.o stm32f3xx_hal_i2s.o stm32f3xx_hal_i2s_ex.o stm32f3xx_hal_irda.o stm32f3xx_hal_iwdg.o stm32f3xx_hal_nand.o stm32f3xx_hal_nor.o stm32f3xx_hal_opamp.o stm32f3xx_hal_opamp_ex.o stm32f3xx_hal_pccard.o stm32f3xx_hal_pcd.o stm32f3xx_hal_pcd_ex.o stm32f3xx_hal_pwr.o stm32f3xx_hal_pwr_ex.o stm32f3xx_hal_rcc.o stm32f3xx_hal_rcc_ex.o stm32f3xx_hal_rtc.o stm32f3xx_hal_rtc_ex.o stm32f3xx_hal_sdadc.o stm32f3xx_hal_smartcard.o stm32f3xx_hal_smartcard_ex.o stm32f3xx_hal_smbus.o stm32f3xx_hal_spi.o stm32f3xx_hal_sram.o stm32f3xx_hal_tim.o stm32f3xx_hal_tim_ex.o stm32f3xx_hal_tsc.o stm32f3xx_hal_uart.o stm32f3xx_hal_uart_ex.o stm32f3xx_hal_usart.o stm32f3xx_hal_wwdg.o stm32f3xx_ll_fmc.o sys.o system_stm32f3xx.o
    ./: main.cpp
