# IAR project LPC_ADNS3080.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2103 NXP LPC2103
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LPC_ADNS3080.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: C:\Documents and Settings\Michael Shimniok\My Documents\Projects\OpticalFlow\LPC_ADNS3080\config\LPC2103_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: delay.c delay.h digital.c digital.h main.c serial.c serial.h spi.c spi.h types.h
